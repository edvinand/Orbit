## remote_controller/build_1/Kconfig/Kconfig.shield.defconfig
```kconfig
osource "C:/Nordic_Semiconductor/SDKs/ncs/v2.1.0/nrf/boards/shields/*/Kconfig.defconfig"
```
